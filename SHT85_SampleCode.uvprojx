# Keil uVision project SHT85_SampleCode.uvprojx, settings and files
target STM32-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SHT85_SampleCode
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./Source/: startup_stm32f10x_md_vl.s
  group Source Files
    ./Source/: i2c_hal.c main.c sht85.c system.c
software components: CMSIS:CORE 5.1.1
